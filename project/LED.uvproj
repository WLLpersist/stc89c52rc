# Keil uVision project LED.uvproj, settings and files
target LED (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user
  group Startup
    ../startup/: STARTUP.A51
  group user
    ../user/: main.c
